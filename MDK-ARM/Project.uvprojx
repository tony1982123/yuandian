# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\Inc;..\Src\components\flash;..\Src\components\func;..\Src\components\hc595;..\Src\components\key;..\Src\components\mixt;..\Src\components\rcc;..\Src\components\Remote;..\Src\components\usart;..\Src\components\system;..\Src\platform\PY32F002B_HAL_Driver\Inc;..\Src\platform\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
  group components
    ../Src/components/flash/: Userflash.c
    ../Src/components/usart/: USART.c
    ../Src/components/func/: func.c
    ../Src/components/hc595/: hc595.c
    ../Src/components/key/: key_drive.c key_event.c
    ../Src/components/mixt/: mixt.c
    ../Src/components/Remote/: remote.c
  group app
    ../Src/app/: main.c
  group platform
    ../Src/platform/BSP/: py32f002b_hal_msp.c py32f002b_it.c system_py32f002b.c
  group Drivers/PY32F002B_HAL_Driver
    ../Src/platform/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
software components: CMSIS:CORE 5.6.0
